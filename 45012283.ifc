Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-15T13:57:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 15 13:57:21 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{51DC4909-D305-49A9-83A7-20AE4790118A}\ifc * Database version: 5507 * Database creation date: Fri Mar 15 13:57:20 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 15 13:57:20 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 15 13:57:20 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 45012283 Washbasin faucet, 45012283:45012283 Washbasin faucet:317362
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalWidth: 50 mm; Projection: 115 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 45012283; ConvergoRefNr: 0087-1803-0007-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 07/03/2019
Type - Green Building Properties(Type) - Approval ACS: 16 ACC NY 205; Customs Code: 84818011; EAN Number: 4057304005596; URL ACS: http://static.hansa.com/ACS/45012283
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.hansa.com/bim/45012283; Catalog Drawing URL: http://static.hansa.com/catdrw/45012283; Class: Single lever; Dimension Drawing URL: http://static.hansa.com/dimdrw/45012283; FDV Document URL: http://www.hansa.com/datasheet/45012283/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/45012283; Group: Washbasin faucet; Manufacturer: Hansa; Market: AUT;BEL;CZE;DEU;ESP;FRA;INT;ITA;NLD;SVK; Model: 45012283 Washbasin faucet; Name_en: 45012283 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 380 x 180 x 74; Package Weight: 1.847 kg; Product Code: 45012283; Product Datasheet: http://www.hansa.com/datasheet/45012283/en; Product Family: HANSAPINTO XL; Product Image URL: http://static.hansa.com/image/45012283; Product URL: http://static.hansa.com/45012283; Type Name: 45012283 Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Aerator: Pressure controlled aerator; Connection Size: G3/8; DN Size: DN15; Extensions: Pop-up waste with draw-rod; Flow: Limitation option for maximum flow-rate; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.hansa.com/manual/45012283; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Mounting Holes: 1 mounting hole; Spare Parts: http://static.hansa.com/sp/45012283; Spout Type: Fixed spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 45012283; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 45012283; Name: 45012283 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x169x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 45012283; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 45012283 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0455505 m2; Volume: 0.00139382 m3
Identity Data - Mark: 16
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 45012283: 45012283 Washbasin faucet; Family and Type: 45012283: 45012283 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 45012283: 45012283 Washbasin faucet; Type Id: 45012283: 45012283 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
